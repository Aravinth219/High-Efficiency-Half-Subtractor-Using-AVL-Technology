* C:\Users\pmuru\eSim-Workspace\SUBTRACTOR\SUBTRACTOR.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/08/22 17:27:08

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
SC14  Net-_SC13-Pad3_ Net-_SC13-Pad3_ Net-_SC1-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__nfet_01v8
SC13  Net-_SC11-Pad3_ Net-_SC11-Pad3_ Net-_SC13-Pad3_ Net-_SC13-Pad3_ sky130_fd_pr__nfet_01v8
SC17  BOW Net-_SC10-Pad2_ GND GND sky130_fd_pr__nfet_01v8
SC2  Net-_SC1-Pad1_ INPUT1 GND GND sky130_fd_pr__nfet_01v8
SC12  BOW INPUT1 GND GND sky130_fd_pr__nfet_01v8
SC18  Net-_SC1-Pad3_ INPUT2 Net-_SC10-Pad2_ Net-_SC10-Pad2_ sky130_fd_pr__nfet_01v8
SC19  Net-_SC10-Pad2_ INPUT2 GND GND sky130_fd_pr__nfet_01v8
SC10  Net-_SC10-Pad1_ Net-_SC10-Pad2_ GND GND sky130_fd_pr__nfet_01v8
SC6  Net-_SC5-Pad3_ INPUT2 GND GND sky130_fd_pr__nfet_01v8
SC9  DIF Net-_SC1-Pad1_ Net-_SC10-Pad1_ Net-_SC10-Pad1_ sky130_fd_pr__nfet_01v8
SC5  DIF INPUT1 Net-_SC5-Pad3_ Net-_SC5-Pad3_ sky130_fd_pr__nfet_01v8
SC1  Net-_SC1-Pad1_ INPUT1 Net-_SC1-Pad3_ Net-_SC1-Pad1_ sky130_fd_pr__pfet_01v8
SC11  Net-_SC1-Pad3_ Net-_SC11-Pad2_ Net-_SC11-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8
SC3  Net-_SC3-Pad1_ INPUT1 Net-_SC1-Pad3_ Net-_SC3-Pad1_ sky130_fd_pr__pfet_01v8
SC4  DIF Net-_SC1-Pad1_ Net-_SC3-Pad1_ DIF sky130_fd_pr__pfet_01v8
SC7  Net-_SC3-Pad1_ INPUT2 Net-_SC1-Pad3_ Net-_SC3-Pad1_ sky130_fd_pr__pfet_01v8
SC8  DIF Net-_SC10-Pad2_ Net-_SC3-Pad1_ DIF sky130_fd_pr__pfet_01v8
SC15  Net-_SC15-Pad1_ INPUT1 Net-_SC1-Pad3_ Net-_SC15-Pad1_ sky130_fd_pr__pfet_01v8
SC16  BOW Net-_SC10-Pad2_ Net-_SC15-Pad1_ BOW sky130_fd_pr__pfet_01v8
v2  Net-_SC11-Pad2_ GND pulse
v1  INPUT1 GND pulse
v4  INPUT2 GND pulse
v3  Net-_SC11-Pad3_ GND DC
scmode1  SKY130mode
U1  DIF plot_v1
U2  BOW plot_v1
U4  INPUT2 plot_v1
U3  INPUT1 plot_v1

.end
